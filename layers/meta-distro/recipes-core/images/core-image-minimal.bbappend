# Core image customizations common to all meta-distro images
require recipes-core/images/core-image-distro.inc
