# Enable native and nativesdk builds for podman-compose
# This allows podman-compose to be used as a build-time tool and in SDK

BBCLASSEXTEND = "native nativesdk"
