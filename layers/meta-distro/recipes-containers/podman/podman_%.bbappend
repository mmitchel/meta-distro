# Enable native and nativesdk builds for podman
# This allows podman to be used as a build-time tool and in SDK

BBCLASSEXTEND = "native nativesdk"
