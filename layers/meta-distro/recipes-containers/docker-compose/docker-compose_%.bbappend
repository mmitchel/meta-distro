# Disable native and nativesdk builds for docker-compose
# Use podman-compose-native for build-time container operations instead

BBCLASSEXTEND = ""
